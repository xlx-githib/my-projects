# Keil uVision project my_Camera_v5.26.uvprojx, settings and files
target my_Camera_v5.26 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: my_Camera_v5.26 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./BSP/DCMI;./BSP/LCD;./BSP/OV2640;./BSP/DELAY;./BSP/KEY;./BSP/PHOTO;./BSP/SD;./FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\my_Camera_v5.26_mydefine.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dcmi.c dma.c fsmc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group OV2640
    ./BSP/OV2640/: ov2640.c ov2640.h ov2640cfg.h sccb.c sccb.h test_rgb565_or_jpeg.c test_rgb565_or_jpeg.h
  group DCMI
    ./BSP/DCMI/: dcmi_app.c dcmi_app.h
  group LCD
    ./BSP/LCD/: lcd.c lcd.h lcdfont.h
  group DELAY
    ./BSP/DELAY/: delay.c delay.h
  group KEY
    ./BSP/KEY/: key.c key.h
  group PHOTO
    ./BSP/PHOTO/: photo.c photo.h
  group SD
    ./BSP/SD/: sdio_sdcard.c sdio_sdcard.h
  group FATFS
    ./FATFS/: ff.c ff.h ffconf.h diskio.c diskio.h
software components: CMSIS:CORE 4.3.0
